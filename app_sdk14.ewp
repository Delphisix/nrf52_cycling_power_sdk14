# IAR project app_sdk14.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52832_XXAA; NRF52; S132; S212; BOARD_GI17003; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; CONFIG_GPIO_AS_PINRESET; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; ANT_STACK_SUPPORT_REQD; SOFTDEVICE_PRESENT; SWI_DISABLE0; DEBUG; NRF_PWR_MGMT_CONFIG_FPU_SUPPORT_ENABLED; BLE_STACK_SUPPORT_REQD; CONFIG_NFCT_PINS_AS_GPIOS; NRF_SD_BLE_API_VERSION=5; APP_NEED_ANT_BPWR; APP_NEED_BLE_NUS
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_channel_config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_encryption; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_fs; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_key_manager; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_key_manager\config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bpwr; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bpwr\pages; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bpwr\simulator; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bpwr\utils; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bsc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bsc\pages; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bsc\simulator; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_bsc\utils; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_common\ant_request_controller; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_common\pages; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_hrm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_hrm\pages; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_hrm\simulator; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_hrm\utils; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_sdm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_sdm\pages; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_sdm\simulator; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_profiles\ant_sdm\utils; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_search_config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_stack_config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_stack_config\config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ant\ant_state_indicator; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\common; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\ble_advertising; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\ble_db_discovery; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\ble_services\ble_nus; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\ble_services\ble_nus_c; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\ble_services\ble_dfu; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\nrf_ble_gatt; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\ble\peer_manager; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\device; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\clock; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\common; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\comp; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\delay; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\gpiote; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\hal; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\i2s; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\lpcomp; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\pdm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\power; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\ppi; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\pwm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\qdec; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\qspi; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\radio_config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\rng; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\rtc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\saadc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\sdio; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\spi_master; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\spi_slave; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\swi; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\systick; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\timer; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\twi_master; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\twis_slave; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\uart; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\usbd; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\drivers_nrf\wdt; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\atomic; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\balloc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\bootloader\dfu; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\bsp; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\button; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\crc16; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\crc32; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\csense; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\csense_drv; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\experimental_section_vars; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\experimental_log; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\experimental_log\src; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\experimental_memobj; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\fds; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\fifo; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\fstorage; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\gpiote; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\hardfault; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\hci; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\led_softblink; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\log; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\log\src; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\low_power_pwm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\mem_manager; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\mutex; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\pwm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\pwr_mgmt; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\queue; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\scheduler; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\slip; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\sensorsim; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\strerror; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\svc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\timer; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\twi; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\uart; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\audio; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\cdc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\cdc\acm; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\hid; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\hid\generic; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\hid\kbd; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\hid\mouse; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\class\msc; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\usbd\config; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\libraries\util; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\softdevice\common; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\softdevice\s332\headers; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\softdevice\s332\headers\nrf52; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\toolchain; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\components\toolchain\cmsis\include; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\external\segger_rtt; D:\SourceRespo\NRF\nRF5_SDK_14.0.0_3bcc1f7\external\fprintf; D:\SourceRespo\NRF\softDevices\ANT_s332_nrf52_5.0.0\ANT_s332_nrf52832_5.0.0.API\include; D:\SourceRespo\NRF\softDevices\ANT_s332_nrf52_5.0.0\ANT_s332_nrf52832_5.0.0.API\include\nrf52; config; board; source; source\boot_common; D:\SourceRespo\haoyi_lib\adc; D:\SourceRespo\haoyi_lib\inertial; D:\SourceRespo\haoyi_lib\communication; D:\SourceRespo\haoyi_lib\dfu; D:\SourceRespo\BSXlite_Cortex_M3_M4_M4F\algo\algo_bsx\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 17003_appsdk14.hex
  ILINK.IlinkOutputFile: 17003_bpwr_debug.out
  ILINK.IlinkIcfFile: D:\wsProj\17003_powerMeter\app\app_sdk14\sd332_v5.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: 17003_bpwr.out
  group Application
    source/: main.c peripheral_if.c
  group Application/AD7124
    $extsource$/haoyi_lib/adc/: ad7124.c
    source/: ad7124_cmd.c ad7124_config.h
  group Application/adc
    source/: app_adc.c
  group Application/ant_bpwr
    source/: app_ant_bpwr.c
  group Application/BIM160
    $extsource$/haoyi_lib/inertial/: bmi160.c bmi160.h
    source/: bmi160_cmd.c bmi160_cmd.h bmi160_config.h
  group Application/ble_uart
    source/: app_ble_nus_peripheral.c app_ble_uart.c
  group Application/Bootloader
    source/bootloader/: antfs_ota.c bl_main.c bootloader.c bootloader_util_arm.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c pstorage.c version.c
  group Application/config
    config/: sdk_config.h sdk_config_ant_bpwr.h
    source/: sdk_config_ble_nus.h
  group Application/dfu
    $extsource$/haoyi_lib/dfu/: nrf52_ble_dfu.c
  group Application/FlashStorage
    source/: sysParams.c
  group Application/Fusion
    source/: fusion_bosch.c kalMan.c
  group Application/ota
    source/: ant_boot_settings_api.c ant_ota.c ota_main.c
  group Application/packetValid
    $extsource$/haoyi_lib/communication/: packetValid.c
  group Board
    board/: boards.c gd17003.h
  group Board Support
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/bsp/: bsp.c bsp_btn_ant.c bsp_btn_ble.c
  group Device
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/toolchain/iar/: iar_startup_nrf52.s
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/toolchain/: system_nrf52.c
  group external
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
  group nRF_ANT
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_channel_config/: ant_channel_config.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_encryption/: ant_encrypt_config.c ant_encrypt_negotiation_slave.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_key_manager/: ant_key_manager.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_search_config/: ant_search_config.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_stack_config/: ant_stack_config.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_state_indicator/: ant_state_indicator.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_fs/: antfs.c crc.c
  group nRF_ANT/profiles/bpwr
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_profiles/ant_bpwr/: ant_bpwr.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_profiles/ant_bpwr/pages/: ant_bpwr_common_data.c ant_bpwr_page_1.c ant_bpwr_page_16.c ant_bpwr_page_17.c ant_bpwr_page_18.c ant_bpwr_page_torque.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_profiles/ant_bpwr/simulator/: ant_bpwr_simulator.c
  group nRF_ANT/profiles/common
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_profiles/ant_common/pages/: ant_common_page_70.c ant_common_page_80.c ant_common_page_81.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ant/ant_profiles/ant_common/ant_request_controller/: ant_request_controller.c
  group nRF_BLE
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_advertising/: ble_advertising.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_db_discovery/: ble_db_discovery.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_racp/: ble_racp.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_radio_notification/: ble_radio_notification.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE/common
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
  group nRF_BLE/peerManage
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_BLE/services
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_services/ble_nus/: ble_nus.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_services/ble_nus_c/: ble_nus_c.c
  group nRF_DFU
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/clock/: nrf_drv_clock.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/common/: nrf_drv_common.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/spi_master/: nrf_drv_spi.c spi_5W_master.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/timer/: nrf_drv_timer.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/fifo/: app_fifo.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/gpiote/: app_gpiote.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/timer/: app_timer.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/uart/: app_uart.c app_uart_fifo.c retarget.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/fds/: fds.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/balloc/: nrf_balloc.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/experimental_memobj/: nrf_memobj.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/experimental_section_vars/: nrf_section_iter.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/strerror/: nrf_strerror.c
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    $extsource$/NRF/nRF5_SDK_14.0.0_3bcc1f7/components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_soc.c
